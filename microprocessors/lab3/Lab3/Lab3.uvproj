# Keil uVision project Lab3.uvproj, settings and files
target Lab3 (ARM-ADS)
  device: STM32F405VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab3
  c flags: Optim=1 wLevel=2
  c misc: --c99
  c include: .\src;.\STM32F4xx_StdPeriph_Driver\inc;.\LIS302DL\inc;.\LIS302DL;.\LIS302DL;.\LIS3DSH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: startup_stm32f4xx.s main.c stm32f4xx_conf.h system_stm32f4xx.c stm32f4xx.h fputc_debug.c atan_LUT.c t2_mems.c t2_mems.h t2_display.c t2_display.h t2_gpio.c t2_gpio.h t2_pwm.c t2_pwm.h t2_servo.c t2_servo.h t2_filtering.c t2_filtering.h
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group LIS302DL
    ./LIS302DL/: stm32f4_discovery_lis302dl.c stm32f4_discovery_lis302dl.h
  group LIS3DSH
    ./LIS3DSH/: lis3dsh.c lis3dsh.h
